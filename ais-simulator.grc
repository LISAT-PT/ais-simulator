options:
  parameters:
    author: Mictronics
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
    run_options: run
    title: Example AIS Transmitter
  states: {}

blocks:
- name: bit_rate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: HackRF requires a minimum of 8Msps!
    value: '96000'
  states: {}
- name: sentence
  id: variable
  parameters:
    value: '''010010000011101011110111001110011000100000000000000000100000001011001000001011000101000110100010010100001101011001111011000011111111111011100101110011100000000000000110'''
  states: {}
- name: ais_simulator_bitstring_to_frame_0
  id: ais_simulator_bitstring_to_frame
  parameters:
    enable_nrzi: 'True'
    len_tag_key: packet_len
  states: {}
- name: ais_simulator_websocket_pdu_0
  id: ais_simulator_websocket_pdu
  parameters:
    addr: 127.0.0.1
    port: '52002'
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: '-15000'
    sample_rate: samp_rate
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate/4
    type: complex
  states: {}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: '0.4'
    samples_per_symbol: int(samp_rate/bit_rate)
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5555
    hwm: '5000'
    timeout: '100'
    type: complex
  states: {}

connections:
- [ais_simulator_bitstring_to_frame_0, '0', digital_gmsk_mod_0, '0']
- [ais_simulator_websocket_pdu_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [blocks_freqshift_cc_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_freqshift_cc_0, '0', zeromq_pub_sink_0, '0']
- [blocks_throttle2_0, '0', blocks_freqshift_cc_0, '0']
- [digital_gmsk_mod_0, '0', blocks_throttle2_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', ais_simulator_bitstring_to_frame_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
